# Autodesk Inventor part: 17-courroie
## iProperties
Created: 2011-02
Part Number: 17-courroie
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Author: eric
