# Autodesk Inventor part: 14-pivot
## iProperties
Created: 2011-02
Part Number: 14-pivot
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Author: eric
## Feature names
1. Base1
