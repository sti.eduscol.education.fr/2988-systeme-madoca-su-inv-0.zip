# Autodesk Inventor part: 8-coussinet
## iProperties
Created: 2011-02
Part Number: 8-coussinet
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Author: eric
## Feature names
1. Base1
