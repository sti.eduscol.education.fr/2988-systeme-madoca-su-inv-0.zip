# Autodesk Inventor part: rotor moteur
## iProperties
Created: 2011-02
Part Number: rotor moteur
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Author: eric
